# Keil uVision project MotorMotionController.uvprojx, settings and files
target MotorMotionController (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: MotorMotionController +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x;..\..\Peripheral\ADC;..\..\Peripheral\Beep;..\..\Peripheral\EXTI;..\..\Peripheral\Key_Board;..\..\Peripheral\LED;..\..\Peripheral\OLED;..\..\Peripheral\Timer;..\..\Peripheral\PVD;..\..\System_Works\Delay;..\..\System_Works\SYS;..\..\STM32F10x_FWLib\include;..\..\STM32F10x_FWLib\src;..\..\Kernel;..\..\Error_Warning;..\..\Peripheral\Temperature;..\OS_Task_Manager;..\..\Malloc;..\..\System_Works\USART2;..\API_Lib\Protocol;..\API_Lib\Data;..\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\uCOS-III;..\UCOSIII\uCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\API_Lib\Sys_Det;..\API_Lib\URC;..\..\Algorithmic\PID;..\..\Peripheral\I2C;..\..\Algorithmic\N_Queen;..\..\Peripheral\RTC;..\Main;..\..\Intergration;..\..\System_Works\USART\USART1;..\..\System_Works\USART\USART2;..\..\Peripheral\DMA;..\..\Peripheral\GPIO;..\Local_TaskMgr;..\API_Lib\DS_Lib;..\..\UI;..\..\Algorithmic\Time_Base;..\..\..\MotorMotionControlModule\Limit_Sensor;..\..\..\MotorMotionControlModule\Motion_Debug\Single_Step;..\..\..\MotorMotionControlModule\Motion_Studio;..\..\..\MotorMotionControlModule\Motor_Config\Sigmod;..\..\..\MotorMotionControlModule\Motor_Config\Tim_Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32F10x_Lib
    ../../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_pwr.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_bkp.c
  group Integration
    ../: stdafx.h
    ../STM32F10x/: stm32f10x_it.c system_stm32f10x.c
    ../Main/: main.c
    ../OS_Task_Manager/: osiii_taskmgr.c
    ../Local_TaskMgr/: local_taskmgr.c
  group API_Lib
    ../API_Lib/URC/: config.c
    ../API_Lib/Protocol/: protocol.c
    ../API_Lib/Data/: data.c
    ../API_Lib/Sys_Det/: sta_req.c
    ../API_Lib/DS_Lib/: datascope_dp.c
  group Algorithmic
    ../../Algorithmic/Time_Base/: time_base.c
    ../../Algorithmic/PID/: pid.c
    ../../Algorithmic/N_Queen/: n_queen.c
  group Malloc
    ../../Malloc/: malloc.c
  group Peripheral
    ../../Peripheral/GPIO/: gpio.c
    ../../Peripheral/Timer/: timer.c
    ../../Peripheral/EXTI/: exti.c
    ../../Peripheral/RTC/: rtc.c
    ../../Peripheral/PVD/: pvd.c sleep.c
    ../../Peripheral/ADC/: adc.c
    ../../Peripheral/DMA/: dma.c
    ../../Peripheral/I2C/: i2c.c
    ../../Peripheral/Temperature/: temperature.c
    ../../Peripheral/OLED/: oled.c
    ../../Peripheral/Key_Board/: key.c
    ../../Peripheral/LED/: led.c
    ../../Peripheral/Beep/: beep.c
  group Kernel
    ../../Kernel/: startup_stm32f10x_hd.s core_cm3.c
  group System_Works
    ../../System_Works/Delay/: delay.c
    ../../System_Works/SYS/: sys.c sys.h
    ../../System_Works/USART/USART1/: usart1.c
    ../../System_Works/USART/USART2/: usart2.c
  group Error_Warning
    ../../Error_Warning/: error_warning.c low_voltage.c
  group UI
    ../../UI/: ui.c
  group MotorMotionControlModule
    ../../../MotorMotionControlModule/Limit_Sensor/: limit_sensor.c
    ../../../MotorMotionControlModule/Motion_Debug/Single_Step/: single_step.c
    ../../../MotorMotionControlModule/Motion_Studio/: motion_studio.c
    ../../../MotorMotionControlModule/Motor_Config/Sigmod/: sigmod.c
    ../../../MotorMotionControlModule/Motor_Config/Tim_Config/: timer1.c
    ../../../: README.md
  group uCOSIII_BSP
    ../UCOSIII/uCOS_BSP/: bsp.c
  group uCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group uCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_c.c os_cpu_a.s
  group uCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group README
    ../../: README.md
    ../../README/: TODO.txt softlog.txt file_standard.txt
